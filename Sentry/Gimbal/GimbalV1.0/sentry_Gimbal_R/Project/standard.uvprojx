# Keil uVision project standard.uvprojx, settings and files
target standard (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sentry_Gimbal_Up +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CMSIS;..\FWLIB\inc;..\User;..\FreeRTOS\include;..\FreeRTOS\portable;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\user\user_lib;..\hardware;..\tasks;..\algo;..\DSP\Include;..\FWLIB\SEGGER_RTT_V784\RTT;..\FWLIB\SEGGER_RTT_V784\Config;..\user\user_math_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../startup/: startup_stm32f40_41xxx.s
  group CMSIS
    ../CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rng.c stm32f4xx_iwdg.c stm32f4xx_dbgmcu.c
    ../FWLIB/SEGGER_RTT_V784/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group user_lib
    ../user/user_math_lib/: user_lib.c
  group main
    ../user/: main.c main.h
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group task
    ../tasks/: start_task.c taskIT_DataReceive.c task_DataSend.c task_StateLED.c task_UsageCPU.c task_ZeroCheck.c task_Shoot.c task_ActionUpdate.c task_CV_DataSend.c task_GimbalR.c task_ins.c
  group freeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group hardware
    ../hardware/: HW_CAN.c HW_GPIO_LED.c HW_DBUS.c HW_USART3_RC.c HW_USART2_PC.c HW_TIM8_pwm.c HW_IWDG.c HW_TIM2_delay.c HW_UART4_debugPC.c counter.c debug.c tim4.c
  group algo
    ../algo/: algo_CRC.c algo_PID.c icm20602.c ins.c kalman_filter.c QuaternionEKF.c TD.c
software components: CMSIS:DSP 1.8.0
