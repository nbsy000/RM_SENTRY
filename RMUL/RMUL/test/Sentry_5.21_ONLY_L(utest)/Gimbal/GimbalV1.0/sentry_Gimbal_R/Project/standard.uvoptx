<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_optx.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj; *.o</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc; *.md</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp</CppX>
    <nMigrate>0</nMigrate>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>standard</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>12000000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>0</RunSim>
        <RunTarget>1</RunTarget>
        <RunAbUc>0</RunAbUc>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\Listings\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>18</CpuCode>
      <DebugOpt>
        <uSim>0</uSim>
        <uTrg>1</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>1</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <tRtrace>1</tRtrace>
        <sRSysVw>1</sRSysVw>
        <tRSysVw>1</tRSysVw>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <bEvRecOn>1</bEvRecOn>
        <bSchkAxf>0</bSchkAxf>
        <bTchkAxf>0</bTchkAxf>
        <nTsel>4</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon>Segger\JL2CM3.dll</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>CMSIS_AGDI</Key>
          <Name>-X"ATK CMSIS-DAP-Debugger" -UATK-05022018 -O206 -S8 -C0 -P00000000 -N00("ARM CoreSight SW-DP") -D00(2BA01477) -L00(0) -TO65554 -TC10000000 -TT10000000 -TP20 -TDS8007 -TDT0 -TDC1F -TIEFFFFFFFF -TIP8 -FO15 -FD20000000 -FC1000 -FN1 -FF0STM32F4xx_1024.FLM -FS08000000 -FL0100000 -FP0($$Device:STM32F405RGTx$CMSIS\Flash\STM32F4xx_1024.FLM)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMRTXEVENTFLAGS</Key>
          <Name>-L70 -Z18 -C0 -M0 -T1</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGTARM</Key>
          <Name>(1010=-1,-1,-1,-1,0)(1007=-1,-1,-1,-1,0)(1008=-1,-1,-1,-1,0)(1009=120,132,378,720,0)(1012=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name></Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGUARM</Key>
          <Name></Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>JL2CM3</Key>
          <Name>-U20090928 -O78 -S2 -ZTIFSpeedSel5000 -A0 -C0 -JU1 -JI127.0.0.1 -JP0 -RST0 -N00("ARM CoreSight SW-DP") -D00(2BA01477) -L00(0) -TO18 -TC10000000 -TP21 -TDS8008 -TDT0 -TDC1F -TIEFFFFFFFF -TIP8 -TB1 -TFE0 -FO15 -FD20000000 -FC1000 -FN1 -FF0STM32F4xx_1024.FLM -FS08000000 -FL0100000 -FP0($$Device:STM32F405RGTx$CMSIS\Flash\STM32F4xx_1024.FLM)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2CM3</Key>
          <Name>UL2CM3(-S0 -C0 -P0 ) -FN1 -FC1000 -FD20000000 -FF0STM32F4xx_1024 -FL0100000 -FS08000000 -FP0($$Device:STM32F405RGTx$CMSIS\Flash\STM32F4xx_1024.FLM)</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <Breakpoint/>
      <WatchWindow1>
        <Ww>
          <count>0</count>
          <WinNumber>1</WinNumber>
          <ItemText>Sentry_State,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>1</count>
          <WinNumber>1</WinNumber>
          <ItemText>CPU_RunTime,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>2</count>
          <WinNumber>1</WinNumber>
          <ItemText>Heat_ShootAbleFlag_0</ItemText>
        </Ww>
        <Ww>
          <count>3</count>
          <WinNumber>1</WinNumber>
          <ItemText>chassis_offline_tick,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>4</count>
          <WinNumber>1</WinNumber>
          <ItemText>chassis_offline_flag,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>5</count>
          <WinNumber>1</WinNumber>
          <ItemText>block_bullet_flag,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>6</count>
          <WinNumber>1</WinNumber>
          <ItemText>block_bullet_tick,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>7</count>
          <WinNumber>1</WinNumber>
          <ItemText>BodanMotor,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>8</count>
          <WinNumber>1</WinNumber>
          <ItemText>MotoPitch,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>9</count>
          <WinNumber>1</WinNumber>
          <ItemText>MotoYaw,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>10</count>
          <WinNumber>1</WinNumber>
          <ItemText>Gyro_White</ItemText>
        </Ww>
        <Ww>
          <count>11</count>
          <WinNumber>1</WinNumber>
          <ItemText>is_game_start</ItemText>
        </Ww>
        <Ww>
          <count>12</count>
          <WinNumber>1</WinNumber>
          <ItemText>Heat_ShootAbleFlag_0</ItemText>
        </Ww>
        <Ww>
          <count>13</count>
          <WinNumber>1</WinNumber>
          <ItemText>Yaw_Actual</ItemText>
        </Ww>
        <Ww>
          <count>14</count>
          <WinNumber>1</WinNumber>
          <ItemText>patrol_step_pitch</ItemText>
        </Ww>
        <Ww>
          <count>15</count>
          <WinNumber>1</WinNumber>
          <ItemText>patrol_step_yaw</ItemText>
        </Ww>
        <Ww>
          <count>16</count>
          <WinNumber>1</WinNumber>
          <ItemText>pc_pitch,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>17</count>
          <WinNumber>1</WinNumber>
          <ItemText>pc_yaw,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>18</count>
          <WinNumber>1</WinNumber>
          <ItemText>aim_yaw,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>19</count>
          <WinNumber>1</WinNumber>
          <ItemText>aim_pitch,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>20</count>
          <WinNumber>1</WinNumber>
          <ItemText>patrol_set_pitch,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>21</count>
          <WinNumber>1</WinNumber>
          <ItemText>Pitch_Actual,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>22</count>
          <WinNumber>1</WinNumber>
          <ItemText>armor_state,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>23</count>
          <WinNumber>1</WinNumber>
          <ItemText>tx2_receive_flag,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>24</count>
          <WinNumber>1</WinNumber>
          <ItemText>tx2_last_receive_flag,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>25</count>
          <WinNumber>1</WinNumber>
          <ItemText>distance,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>26</count>
          <WinNumber>1</WinNumber>
          <ItemText>run_time_check,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>27</count>
          <WinNumber>1</WinNumber>
          <ItemText>patrol_set_pitch</ItemText>
        </Ww>
        <Ww>
          <count>28</count>
          <WinNumber>1</WinNumber>
          <ItemText>SendToPC_Buff,0x10</ItemText>
        </Ww>
        <Ww>
          <count>29</count>
          <WinNumber>1</WinNumber>
          <ItemText>yaw,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>30</count>
          <WinNumber>1</WinNumber>
          <ItemText>pitch,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>31</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/taskIT_DataReceive.c\run_time_check</ItemText>
        </Ww>
        <Ww>
          <count>32</count>
          <WinNumber>1</WinNumber>
          <ItemText>distance,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>33</count>
          <WinNumber>1</WinNumber>
          <ItemText>RC_Ctl,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>34</count>
          <WinNumber>1</WinNumber>
          <ItemText>Test_Pitch_Pos,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>35</count>
          <WinNumber>1</WinNumber>
          <ItemText>aim_pitch,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>36</count>
          <WinNumber>1</WinNumber>
          <ItemText>aim_yaw,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>37</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/taskIT_DataReceive.c\aim_pitch</ItemText>
        </Ww>
        <Ww>
          <count>38</count>
          <WinNumber>1</WinNumber>
          <ItemText>SendToPC_Buff,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>39</count>
          <WinNumber>1</WinNumber>
          <ItemText>FrictionMotor[0],0x0A</ItemText>
        </Ww>
        <Ww>
          <count>40</count>
          <WinNumber>1</WinNumber>
          <ItemText>FrictionMotor[1],0x0A</ItemText>
        </Ww>
        <Ww>
          <count>41</count>
          <WinNumber>1</WinNumber>
          <ItemText>Test_Yaw_Pos</ItemText>
        </Ww>
        <Ww>
          <count>42</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/task_GimbalUp.c\MotoYaw,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>43</count>
          <WinNumber>1</WinNumber>
          <ItemText>Test_Pitch_Pos</ItemText>
        </Ww>
        <Ww>
          <count>44</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/task_GimbalUp.c\MotoPitch,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>45</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/taskIT_DataReceive.c\Gyro_White.GZ</ItemText>
        </Ww>
        <Ww>
          <count>46</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/taskIT_DataReceive.c\Gyro_White.PITCH</ItemText>
        </Ww>
        <Ww>
          <count>47</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/task_ShootUp.c\is_game_start</ItemText>
        </Ww>
        <Ww>
          <count>48</count>
          <WinNumber>1</WinNumber>
          <ItemText>PC_TX_num,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>49</count>
          <WinNumber>1</WinNumber>
          <ItemText>TX_Number,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>50</count>
          <WinNumber>1</WinNumber>
          <ItemText>RX_Number,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>51</count>
          <WinNumber>1</WinNumber>
          <ItemText>block_bullet_flag,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>52</count>
          <WinNumber>1</WinNumber>
          <ItemText>BodanDelay_OVER,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>53</count>
          <WinNumber>1</WinNumber>
          <ItemText>BodanDelay_Tick,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>54</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/task_ShootUp.c\BodanMotor,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>55</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/task_ShootUp.c\BodanMotor.Angle_Inc</ItemText>
        </Ww>
        <Ww>
          <count>56</count>
          <WinNumber>1</WinNumber>
          <ItemText>SendToPC_Buff,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>57</count>
          <WinNumber>1</WinNumber>
          <ItemText>PCbuffer,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>58</count>
          <WinNumber>1</WinNumber>
          <ItemText>armor_state,0x10</ItemText>
        </Ww>
        <Ww>
          <count>59</count>
          <WinNumber>1</WinNumber>
          <ItemText>aim_yaw</ItemText>
        </Ww>
        <Ww>
          <count>60</count>
          <WinNumber>1</WinNumber>
          <ItemText>aim_pitch</ItemText>
        </Ww>
        <Ww>
          <count>61</count>
          <WinNumber>1</WinNumber>
          <ItemText>tempPC,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>62</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/taskIT_DataReceive.c\armor_state</ItemText>
        </Ww>
        <Ww>
          <count>63</count>
          <WinNumber>1</WinNumber>
          <ItemText>Pitch_Actual</ItemText>
        </Ww>
        <Ww>
          <count>64</count>
          <WinNumber>1</WinNumber>
          <ItemText>Yaw_Actual</ItemText>
        </Ww>
        <Ww>
          <count>65</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/task_GimbalUp.c\MotoPitch,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>66</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/task_GimbalUp.c\MotoYaw,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>67</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/taskIT_DataReceive.c\aim_yaw</ItemText>
        </Ww>
        <Ww>
          <count>68</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/taskIT_DataReceive.c\aim_pitch</ItemText>
        </Ww>
        <Ww>
          <count>69</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/taskIT_DataReceive.c\aim_yaw</ItemText>
        </Ww>
        <Ww>
          <count>70</count>
          <WinNumber>1</WinNumber>
          <ItemText>Last_Pc_Rx_Num,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>71</count>
          <WinNumber>1</WinNumber>
          <ItemText>Pc_RX_Num,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>72</count>
          <WinNumber>1</WinNumber>
          <ItemText>patrol_set_pitch,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>73</count>
          <WinNumber>1</WinNumber>
          <ItemText>patrol_set_yaw,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>74</count>
          <WinNumber>1</WinNumber>
          <ItemText>bodanLastPos,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>75</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/task_ShootUp.c\bodanLastPos</ItemText>
        </Ww>
        <Ww>
          <count>76</count>
          <WinNumber>1</WinNumber>
          <ItemText>chassis_speed_trans_100,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>77</count>
          <WinNumber>1</WinNumber>
          <ItemText>chassis_speed_trans</ItemText>
        </Ww>
        <Ww>
          <count>78</count>
          <WinNumber>1</WinNumber>
          <ItemText>chassis_speed,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>79</count>
          <WinNumber>1</WinNumber>
          <ItemText>Can1_rx_message_1,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>80</count>
          <WinNumber>1</WinNumber>
          <ItemText>RC_Bodan,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>81</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/task_ShootUp.c\BodanMotor,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>82</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/task_ShootUp.c\BodanDelay_OVER,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>83</count>
          <WinNumber>1</WinNumber>
          <ItemText>block_bullet_flag,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>84</count>
          <WinNumber>1</WinNumber>
          <ItemText>bodanLastPos,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>85</count>
          <WinNumber>1</WinNumber>
          <ItemText>aim_Up_Pitch,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>86</count>
          <WinNumber>1</WinNumber>
          <ItemText>aim_Up_Yaw,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>87</count>
          <WinNumber>1</WinNumber>
          <ItemText>aim_Valid_Flag,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>88</count>
          <WinNumber>1</WinNumber>
          <ItemText>Interval,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>89</count>
          <WinNumber>1</WinNumber>
          <ItemText>Test_Pitch_Pos,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>90</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/task_GimbalUp.c\MotoPitch,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>91</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/task_GimbalUp.c\Pitch_Actual,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>92</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/task_GimbalUp.c\patrol_set_pitch</ItemText>
        </Ww>
        <Ww>
          <count>93</count>
          <WinNumber>1</WinNumber>
          <ItemText>Positive_Flag,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>94</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/task_ShootUp.c\BodanMotor,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>95</count>
          <WinNumber>1</WinNumber>
          <ItemText>block_bullet_flag,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>96</count>
          <WinNumber>1</WinNumber>
          <ItemText>CV_Shoot_ABLE</ItemText>
        </Ww>
        <Ww>
          <count>97</count>
          <WinNumber>1</WinNumber>
          <ItemText>BodanDelay_OVER,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>98</count>
          <WinNumber>1</WinNumber>
          <ItemText>block_bullet_tick,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>99</count>
          <WinNumber>1</WinNumber>
          <ItemText>CAN2_tx_down,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>100</count>
          <WinNumber>1</WinNumber>
          <ItemText>last_armor_state,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>101</count>
          <WinNumber>1</WinNumber>
          <ItemText>armor_state,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>102</count>
          <WinNumber>1</WinNumber>
          <ItemText>Pc_RX_Num,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>103</count>
          <WinNumber>1</WinNumber>
          <ItemText>Last_Pc_Rx_Num,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>104</count>
          <WinNumber>1</WinNumber>
          <ItemText>pc_pitch_down,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>105</count>
          <WinNumber>1</WinNumber>
          <ItemText>pc_yaw_down,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>106</count>
          <WinNumber>1</WinNumber>
          <ItemText>tempPC,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>107</count>
          <WinNumber>1</WinNumber>
          <ItemText>CAN2_tx_message_remote,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>108</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/taskIT_DataReceive.c\pc_pitch,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>109</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/taskIT_DataReceive.c\pc_yaw,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>110</count>
          <WinNumber>1</WinNumber>
          <ItemText>CV_Shoot_ABLE,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>111</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/taskIT_DataReceive.c\aim_yaw,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>112</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/taskIT_DataReceive.c\aim_pitch,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>113</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/task_GimbalUp.c\Yaw_Actual,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>114</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/task_GimbalUp.c\Pitch_Actual,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>115</count>
          <WinNumber>1</WinNumber>
          <ItemText>Attack_color,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>116</count>
          <WinNumber>1</WinNumber>
          <ItemText>Bullet_Speed,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>117</count>
          <WinNumber>1</WinNumber>
          <ItemText>send_bullet_speed,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>118</count>
          <WinNumber>1</WinNumber>
          <ItemText>distance,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>119</count>
          <WinNumber>1</WinNumber>
          <ItemText>delayTick_oneShot,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>120</count>
          <WinNumber>1</WinNumber>
          <ItemText>PCbuffer,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>121</count>
          <WinNumber>1</WinNumber>
          <ItemText>GimbalUp_ModeUpdate_Flag,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>122</count>
          <WinNumber>1</WinNumber>
          <ItemText>PC_Send</ItemText>
        </Ww>
        <Ww>
          <count>123</count>
          <WinNumber>1</WinNumber>
          <ItemText>PC_Recv</ItemText>
        </Ww>
        <Ww>
          <count>124</count>
          <WinNumber>1</WinNumber>
          <ItemText>PC_SendBuf</ItemText>
        </Ww>
        <Ww>
          <count>125</count>
          <WinNumber>1</WinNumber>
          <ItemText>PCbuffer</ItemText>
        </Ww>
        <Ww>
          <count>126</count>
          <WinNumber>1</WinNumber>
          <ItemText>RC_Ctl,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>127</count>
          <WinNumber>1</WinNumber>
          <ItemText>yaw_r</ItemText>
        </Ww>
      </WatchWindow1>
      <WatchWindow2>
        <Ww>
          <count>0</count>
          <WinNumber>2</WinNumber>
          <ItemText>MotoPitch,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>1</count>
          <WinNumber>2</WinNumber>
          <ItemText>MotoYaw,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>2</count>
          <WinNumber>2</WinNumber>
          <ItemText>MotoPitch_L,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>3</count>
          <WinNumber>2</WinNumber>
          <ItemText>MotoYaw_L,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>4</count>
          <WinNumber>2</WinNumber>
          <ItemText>RC_Ctl</ItemText>
        </Ww>
        <Ww>
          <count>5</count>
          <WinNumber>2</WinNumber>
          <ItemText>FrameRate</ItemText>
        </Ww>
        <Ww>
          <count>6</count>
          <WinNumber>2</WinNumber>
          <ItemText>Debug_Mode,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>7</count>
          <WinNumber>2</WinNumber>
          <ItemText>Sentry_State</ItemText>
        </Ww>
        <Ww>
          <count>8</count>
          <WinNumber>2</WinNumber>
          <ItemText>Test_Pitch_Pos</ItemText>
        </Ww>
        <Ww>
          <count>9</count>
          <WinNumber>2</WinNumber>
          <ItemText>Test_Yaw_Pos</ItemText>
        </Ww>
        <Ww>
          <count>10</count>
          <WinNumber>2</WinNumber>
          <ItemText>debug_pitch,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>11</count>
          <WinNumber>2</WinNumber>
          <ItemText>debug_yaw,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>12</count>
          <WinNumber>2</WinNumber>
          <ItemText>MotoYaw.actualAngle</ItemText>
        </Ww>
        <Ww>
          <count>13</count>
          <WinNumber>2</WinNumber>
          <ItemText>MotoPitch.actualAngle</ItemText>
        </Ww>
        <Ww>
          <count>14</count>
          <WinNumber>2</WinNumber>
          <ItemText>MotoPitch.Gyro_Speed</ItemText>
        </Ww>
        <Ww>
          <count>15</count>
          <WinNumber>2</WinNumber>
          <ItemText>MotoYaw.Gyro_Speed</ItemText>
        </Ww>
        <Ww>
          <count>16</count>
          <WinNumber>2</WinNumber>
          <ItemText>speed_debug,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>17</count>
          <WinNumber>2</WinNumber>
          <ItemText>test_pitch_speed</ItemText>
        </Ww>
        <Ww>
          <count>18</count>
          <WinNumber>2</WinNumber>
          <ItemText>test_yaw_speed</ItemText>
        </Ww>
        <Ww>
          <count>19</count>
          <WinNumber>2</WinNumber>
          <ItemText>A_Speed_Pitch</ItemText>
        </Ww>
        <Ww>
          <count>20</count>
          <WinNumber>2</WinNumber>
          <ItemText>count,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>21</count>
          <WinNumber>2</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/task_GimbalR.c\MotoPitch,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>22</count>
          <WinNumber>2</WinNumber>
          <ItemText>aim_yaw</ItemText>
        </Ww>
        <Ww>
          <count>23</count>
          <WinNumber>2</WinNumber>
          <ItemText>aim_pitch</ItemText>
        </Ww>
        <Ww>
          <count>24</count>
          <WinNumber>2</WinNumber>
          <ItemText>Gimbal_L</ItemText>
        </Ww>
        <Ww>
          <count>25</count>
          <WinNumber>2</WinNumber>
          <ItemText>aim_pitch_l</ItemText>
        </Ww>
        <Ww>
          <count>26</count>
          <WinNumber>2</WinNumber>
          <ItemText>aim_yaw_l</ItemText>
        </Ww>
        <Ww>
          <count>27</count>
          <WinNumber>2</WinNumber>
          <ItemText>aim_yaw</ItemText>
        </Ww>
        <Ww>
          <count>28</count>
          <WinNumber>2</WinNumber>
          <ItemText>aim_pitch</ItemText>
        </Ww>
        <Ww>
          <count>29</count>
          <WinNumber>2</WinNumber>
          <ItemText>Fuzzy_Flag,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>30</count>
          <WinNumber>2</WinNumber>
          <ItemText>FrictionMotor,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>31</count>
          <WinNumber>2</WinNumber>
          <ItemText>BodanMotor</ItemText>
        </Ww>
        <Ww>
          <count>32</count>
          <WinNumber>2</WinNumber>
          <ItemText>Heat_ShootAbleFlag</ItemText>
        </Ww>
        <Ww>
          <count>33</count>
          <WinNumber>2</WinNumber>
          <ItemText>delayTick_oneShot,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>34</count>
          <WinNumber>2</WinNumber>
          <ItemText>Gimbal_R.armor_state</ItemText>
        </Ww>
        <Ww>
          <count>35</count>
          <WinNumber>2</WinNumber>
          <ItemText>Gimbal_R</ItemText>
        </Ww>
        <Ww>
          <count>36</count>
          <WinNumber>2</WinNumber>
          <ItemText>PC_Receive</ItemText>
        </Ww>
        <Ww>
          <count>37</count>
          <WinNumber>2</WinNumber>
          <ItemText>armor_flag</ItemText>
        </Ww>
        <Ww>
          <count>38</count>
          <WinNumber>2</WinNumber>
          <ItemText>ChassisYaw_Inc</ItemText>
        </Ww>
        <Ww>
          <count>39</count>
          <WinNumber>2</WinNumber>
          <ItemText>MotoYaw_L.PCsetAngle</ItemText>
        </Ww>
        <Ww>
          <count>40</count>
          <WinNumber>2</WinNumber>
          <ItemText>MotoYaw.PCsetAngle</ItemText>
        </Ww>
        <Ww>
          <count>41</count>
          <WinNumber>2</WinNumber>
          <ItemText>delayTick_oneShot,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>42</count>
          <WinNumber>2</WinNumber>
          <ItemText>K_LP</ItemText>
        </Ww>
        <Ww>
          <count>43</count>
          <WinNumber>2</WinNumber>
          <ItemText>K_LP</ItemText>
        </Ww>
        <Ww>
          <count>44</count>
          <WinNumber>2</WinNumber>
          <ItemText>target_id,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>45</count>
          <WinNumber>2</WinNumber>
          <ItemText>PCReceivebuffer</ItemText>
        </Ww>
        <Ww>
          <count>46</count>
          <WinNumber>2</WinNumber>
          <ItemText>target_id_l</ItemText>
        </Ww>
        <Ww>
          <count>47</count>
          <WinNumber>2</WinNumber>
          <ItemText>K_pitch</ItemText>
        </Ww>
        <Ww>
          <count>48</count>
          <WinNumber>2</WinNumber>
          <ItemText>\\sentry_Gimbal_Up\../tasks/task_GimbalR.c\MotoPitch.PidPos.SetPoint</ItemText>
        </Ww>
        <Ww>
          <count>49</count>
          <WinNumber>2</WinNumber>
          <ItemText>K_pitch</ItemText>
        </Ww>
        <Ww>
          <count>50</count>
          <WinNumber>2</WinNumber>
          <ItemText>K_yaw</ItemText>
        </Ww>
        <Ww>
          <count>51</count>
          <WinNumber>2</WinNumber>
          <ItemText>Heat_ShootAbleFlag</ItemText>
        </Ww>
        <Ww>
          <count>52</count>
          <WinNumber>2</WinNumber>
          <ItemText>MotoPitch.Gyro_Speed</ItemText>
        </Ww>
        <Ww>
          <count>53</count>
          <WinNumber>2</WinNumber>
          <ItemText>PCbuffer</ItemText>
        </Ww>
        <Ww>
          <count>54</count>
          <WinNumber>2</WinNumber>
          <ItemText>PC_SENDBUF_SIZE</ItemText>
        </Ww>
        <Ww>
          <count>55</count>
          <WinNumber>2</WinNumber>
          <ItemText>SendToPC_Buff</ItemText>
        </Ww>
        <Ww>
          <count>56</count>
          <WinNumber>2</WinNumber>
          <ItemText>Attack_color</ItemText>
        </Ww>
        <Ww>
          <count>57</count>
          <WinNumber>2</WinNumber>
          <ItemText>inc_pitch</ItemText>
        </Ww>
        <Ww>
          <count>58</count>
          <WinNumber>2</WinNumber>
          <ItemText>inc_yaw</ItemText>
        </Ww>
        <Ww>
          <count>59</count>
          <WinNumber>2</WinNumber>
          <ItemText>K_AIM_pitch</ItemText>
        </Ww>
        <Ww>
          <count>60</count>
          <WinNumber>2</WinNumber>
          <ItemText>K_AIM_yaw</ItemText>
        </Ww>
        <Ww>
          <count>61</count>
          <WinNumber>2</WinNumber>
          <ItemText>time_cnt_l,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>62</count>
          <WinNumber>2</WinNumber>
          <ItemText>Gyro_ChassisYaw</ItemText>
        </Ww>
        <Ww>
          <count>63</count>
          <WinNumber>2</WinNumber>
          <ItemText>Gyro_Right</ItemText>
        </Ww>
        <Ww>
          <count>64</count>
          <WinNumber>2</WinNumber>
          <ItemText>Gyro_Left</ItemText>
        </Ww>
      </WatchWindow2>
      <MemoryWindow1>
        <Mm>
          <WinNumber>1</WinNumber>
          <SubType>0</SubType>
          <ItemText>xTickCount</ItemText>
          <AccSizeX>0</AccSizeX>
        </Mm>
      </MemoryWindow1>
      <Tracepoint>
        <THDelay>0</THDelay>
      </Tracepoint>
      <DebugFlag>
        <trace>0</trace>
        <periodic>1</periodic>
        <aLwin>1</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>1</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
      <bLintAuto>0</bLintAuto>
      <bAutoGenD>0</bAutoGenD>
      <LntExFlags>0</LntExFlags>
      <pMisraName></pMisraName>
      <pszMrule></pszMrule>
      <pSingCmds></pSingCmds>
      <pMultCmds></pMultCmds>
      <pMisraNamep></pMisraNamep>
      <pszMrulep></pszMrulep>
      <pSingCmdsp></pSingCmdsp>
      <pMultCmdsp></pMultCmdsp>
      <DebugDescription>
        <Enable>1</Enable>
        <EnableFlashSeq>0</EnableFlashSeq>
        <EnableLog>0</EnableLog>
        <Protocol>2</Protocol>
        <DbgClock>10000000</DbgClock>
      </DebugDescription>
    </TargetOption>
  </Target>

  <Group>
    <GroupName>STARTUP</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>1</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\startup\startup_stm32f40_41xxx.s</PathWithFileName>
      <FilenameWithoutPath>startup_stm32f40_41xxx.s</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>CMSIS</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>2</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\CMSIS\stm32f4xx_it.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_it.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>3</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\CMSIS\system_stm32f4xx.c</PathWithFileName>
      <FilenameWithoutPath>system_stm32f4xx.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>FWLIB</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>4</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FWLIB\src\misc.c</PathWithFileName>
      <FilenameWithoutPath>misc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>5</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FWLIB\src\stm32f4xx_can.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_can.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>6</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FWLIB\src\stm32f4xx_dma.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_dma.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>7</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FWLIB\src\stm32f4xx_exti.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_exti.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>8</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FWLIB\src\stm32f4xx_flash.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_flash.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>9</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FWLIB\src\stm32f4xx_gpio.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_gpio.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>10</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FWLIB\src\stm32f4xx_rcc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_rcc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>11</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FWLIB\src\stm32f4xx_syscfg.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_syscfg.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>12</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FWLIB\src\stm32f4xx_tim.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_tim.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>13</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FWLIB\src\stm32f4xx_usart.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_usart.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>14</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FWLIB\src\stm32f4xx_rng.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_rng.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>15</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FWLIB\src\stm32f4xx_iwdg.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_iwdg.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>16</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FWLIB\SEGGER_RTT_V784\RTT\SEGGER_RTT.c</PathWithFileName>
      <FilenameWithoutPath>SEGGER_RTT.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>17</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FWLIB\SEGGER_RTT_V784\RTT\SEGGER_RTT_printf.c</PathWithFileName>
      <FilenameWithoutPath>SEGGER_RTT_printf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>18</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FWLIB\src\stm32f4xx_dbgmcu.c</PathWithFileName>
      <FilenameWithoutPath>stm32f4xx_dbgmcu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>user_lib</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>19</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\user_math_lib\user_lib.c</PathWithFileName>
      <FilenameWithoutPath>user_lib.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>main</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>20</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>21</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\user\main.h</PathWithFileName>
      <FilenameWithoutPath>main.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>22</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FreeRTOS\include\FreeRTOSConfig.h</PathWithFileName>
      <FilenameWithoutPath>FreeRTOSConfig.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>task</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>23</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\tasks\start_task.c</PathWithFileName>
      <FilenameWithoutPath>start_task.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>24</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\tasks\taskIT_DataReceive.c</PathWithFileName>
      <FilenameWithoutPath>taskIT_DataReceive.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>25</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\tasks\task_DataSend.c</PathWithFileName>
      <FilenameWithoutPath>task_DataSend.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>26</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\tasks\task_StateLED.c</PathWithFileName>
      <FilenameWithoutPath>task_StateLED.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>27</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\tasks\task_UsageCPU.c</PathWithFileName>
      <FilenameWithoutPath>task_UsageCPU.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>28</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\tasks\task_ZeroCheck.c</PathWithFileName>
      <FilenameWithoutPath>task_ZeroCheck.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>29</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\tasks\task_Shoot.c</PathWithFileName>
      <FilenameWithoutPath>task_Shoot.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>30</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\tasks\task_ActionUpdate.c</PathWithFileName>
      <FilenameWithoutPath>task_ActionUpdate.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>31</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\tasks\task_CV_DataSend.c</PathWithFileName>
      <FilenameWithoutPath>task_CV_DataSend.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>32</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\tasks\task_GimbalR.c</PathWithFileName>
      <FilenameWithoutPath>task_GimbalR.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>33</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\tasks\task_ins.c</PathWithFileName>
      <FilenameWithoutPath>task_ins.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>freeRTOS</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>34</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FreeRTOS\croutine.c</PathWithFileName>
      <FilenameWithoutPath>croutine.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>35</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FreeRTOS\event_groups.c</PathWithFileName>
      <FilenameWithoutPath>event_groups.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>36</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FreeRTOS\list.c</PathWithFileName>
      <FilenameWithoutPath>list.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>37</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FreeRTOS\queue.c</PathWithFileName>
      <FilenameWithoutPath>queue.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>38</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FreeRTOS\tasks.c</PathWithFileName>
      <FilenameWithoutPath>tasks.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>39</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FreeRTOS\timers.c</PathWithFileName>
      <FilenameWithoutPath>timers.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>40</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FreeRTOS\portable\RVDS\ARM_CM4F\port.c</PathWithFileName>
      <FilenameWithoutPath>port.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>41</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\FreeRTOS\portable\MemMang\heap_4.c</PathWithFileName>
      <FilenameWithoutPath>heap_4.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>hardware</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>42</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\hardware\HW_CAN.c</PathWithFileName>
      <FilenameWithoutPath>HW_CAN.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>43</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\hardware\HW_GPIO_LED.c</PathWithFileName>
      <FilenameWithoutPath>HW_GPIO_LED.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>44</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\hardware\HW_DBUS.c</PathWithFileName>
      <FilenameWithoutPath>HW_DBUS.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>45</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\hardware\HW_USART3_RC.c</PathWithFileName>
      <FilenameWithoutPath>HW_USART3_RC.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>46</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\hardware\HW_USART2_PC.c</PathWithFileName>
      <FilenameWithoutPath>HW_USART2_PC.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>47</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\hardware\HW_TIM8_pwm.c</PathWithFileName>
      <FilenameWithoutPath>HW_TIM8_pwm.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>48</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\hardware\HW_IWDG.c</PathWithFileName>
      <FilenameWithoutPath>HW_IWDG.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>49</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\hardware\HW_TIM2_delay.c</PathWithFileName>
      <FilenameWithoutPath>HW_TIM2_delay.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>50</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\hardware\HW_UART4_debugPC.c</PathWithFileName>
      <FilenameWithoutPath>HW_UART4_debugPC.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>51</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\hardware\counter.c</PathWithFileName>
      <FilenameWithoutPath>counter.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>52</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\hardware\debug.c</PathWithFileName>
      <FilenameWithoutPath>debug.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>53</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\hardware\tim4.c</PathWithFileName>
      <FilenameWithoutPath>tim4.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>algo</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>54</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\algo\algo_CRC.c</PathWithFileName>
      <FilenameWithoutPath>algo_CRC.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>55</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\algo\algo_PID.c</PathWithFileName>
      <FilenameWithoutPath>algo_PID.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>56</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\algo\icm20602.c</PathWithFileName>
      <FilenameWithoutPath>icm20602.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>57</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\algo\ins.c</PathWithFileName>
      <FilenameWithoutPath>ins.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>58</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\algo\kalman_filter.c</PathWithFileName>
      <FilenameWithoutPath>kalman_filter.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>59</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\algo\QuaternionEKF.c</PathWithFileName>
      <FilenameWithoutPath>QuaternionEKF.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>::CMSIS</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>1</RteFlg>
  </Group>

</ProjectOpt>
