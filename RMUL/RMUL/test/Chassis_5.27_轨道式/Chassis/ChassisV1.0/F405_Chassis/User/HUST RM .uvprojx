# Keil uVision project HUST RM .uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HUST RM
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx, ARM_MATH_CM4, __FPU_PRESENT=1, __FPU_USED =1, __CC_ARM,__TARGET_FPU_VFP
  c include: ..\User;..\Mylib;..\Library\CMSIS;..\Library\inc;..\Library\src;..\Task;..\Mylib;..\FreeRTOS\src;..\FreeRTOS\port\MemMang;..\FreeRTOS\port\RVDS\ARM_CM4F;..\FreeRTOS\include;..\Algorithm;..\Hardware;..\FATFS;..\Library\SEGGER_RTT_V784\RTT;..\Library\SEGGER_RTT_V784\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c FreeRTOSConfig.h
  group Algorithm
    ../Algorithm/: algorithmOfCRC.c FIR.c pid.c Path.c Navi_Path.c algo_HeatControl.c icm20602.c ins.c kalman_filter.c QuaternionEKF.c
  group Library
    ../Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_iwdg.c stm32f4xx_dac.c stm32f4xx_spi.c stm32f4xx_dbgmcu.c
    ../Library/CMSIS/: startup_stm32f40_41xxx.s
    ../Library/SEGGER_RTT_V784/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Task
    ../Task/: DataReceiveTask.c DataSendTask.c ChassisTask.c StartTask.c task_ActionUpdate.c ZeroCheckTask.c JudgeTask.c SDCardTask.c CPU_Task.c task_ins.c ChassisYawTask.c
  group FreeRTOS/Src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group Hardware
    ../Hardware/: can1.c can2.c iwdg.c tim2.c tim4.c i2c.c ina260.c dac.c uart4.c RMD_L_CONTROL.c usart2.c bsp_spi_sdcard.c counter.c debug.c
  group DSP
    ../Library/CMSIS/MathLib/: arm_mat_init_f32.c arm_mat_mult_f32.c arm_mat_add_f32.c arm_mat_scale_f32.c arm_mat_sub_f32.c
  group FATFS
    ../FATFS/: diskio.c ff.c
    ../FATFS/option/: cc936.c
software components: CMSIS:DSP 1.7.0
